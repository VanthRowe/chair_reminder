# Keil uVision project chair_reminder.uvprojx, settings and files
target chair_reminder (6240000::V6.24::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: chair_reminder +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32L233
  c include: .\drivers\bsp;.\drivers\device;.\components\log
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: main.c
  group drivers/bsp
    ./drivers/bsp/: bsp_gpio.c bsp_timer.c bsp_pwm.c bsp_adc.c bsp_dac.c bsp_usart.c bsp_i2c.c bsp_spi.c bsp_rtc.c bsp_fwdgt.c bsp_wwdgt.c
    ./RTE/Device/GD32L233RC/: gd32l23x_adc.c gd32l23x_dac.c
  group components/log
    ./components/log/: log.c
  group drivers/device
    ./drivers/device/: device_led.c
software components: CMSIS:CORE 6.1.1, Device:GD32L23x_StdPeripherals:CMP 2.4.0, Device:GD32L23x_StdPeripherals:CRC 2.4.0, Device:GD32L23x_StdPeripherals:DMA 2.4.0, Device:GD32L23x_StdPeripherals:EXTI 2.4.0, Device:GD32L23x_StdPeripherals:FMC 2.4.0, Device:GD32L23x_StdPeripherals:FWDGT 2.4.0, Device:GD32L23x_StdPeripherals:GPIO 2.4.0, Device:GD32L23x_StdPeripherals:I2C 2.4.0, Device:GD32L23x_StdPeripherals:LPTIMER 2.4.0, Device:GD32L23x_StdPeripherals:LPUART 2.4.0, Device:GD32L23x_StdPeripherals:MISC 2.4.0, Device:GD32L23x_StdPeripherals:PMU 2.4.0, Device:GD32L23x_StdPeripherals:RCU 2.4.0, Device:GD32L23x_StdPeripherals:RTC 2.4.0, Device:GD32L23x_StdPeripherals:SLCD 2.4.0, Device:GD32L23x_StdPeripherals:SPI_I2S 2.4.0, Device:GD32L23x_StdPeripherals:TIMER 2.4.0, Device:GD32L23x_StdPeripherals:USART 2.4.0, Device:GD32L23x_StdPeripherals:WWDGT 2.4.0, Device:Startup 2.4.0
